# Keil uVision project LoRaNode.uvprojx, settings and files
target LoRaNode (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L073CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SloveV13 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L073xx,USE_MODEM_LORA,USE_BAND_433,USING_RS485
  c misc: --C99
  c include: ..\CMSIS\Device\ST\STM32L0xx\Include;..\CMSIS\Include;..\stm32L0xx_HAL\Inc\Legacy;..\stm32L0xx_HAL\Inc;..\USER;..\HAL\sensor\inc;..\HAL\system;..\HAL\inc;..\Lib\LoRawan-node\misc;..\Lib\LoRawan-node\radio;..\Lib\LoRawan-node\radio\sx1276;..\Lib\LoRawan-node\mac;..\Lib\LoRawan-node\crypto;..\Lib;..\contiki-3.0\cpu\arm\stm32f103;..\contiki-3.0\core\sys;..\contiki-3.0\core;..\contiki-3.0\cpu\stm32w108;..\contiki-3.0\core\lib;..\contiki-3.0\core\net\mac\contikimac;..\contiki-3.0\core\net\rime;..\contiki-3.0\core\net\;..\contiki-3.0\core\dev;..\contiki-3.0\core\net\llsec;..\contiki-3.0\core\net\llsec\noncoresec
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l073xx.s
    ../CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group stm32L0xx_HAL
    ../stm32L0xx_HAL/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c stm32l0xx_ll_adc.c stm32l0xx_ll_comp.c stm32l0xx_ll_crc.c stm32l0xx_ll_crs.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rng.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_utils.c
  group HAL\src
    ../HAL/src/: usart.c spi.c rtc-board.c delay.c timer-board.c sx1276-board.c gpio-board.c adc.c timerserver.c iwdg.c bq24195.c i2c.c power.c user_bq24195.c
  group HAL\system
    ../HAL/system/: board.c gpio.c stmflash.c led.c
  group HAL\sensor\src
    ../HAL/sensor/src/: gps.c HDC1080.c max44009.c rs485.c sensor.c si7021.c
  group Lib\LoRawan-node
    ../Lib/LoRawan-node/radio/sx1276/: sx1276.c
    ../Lib/LoRawan-node/mac/: LoRaMac.c LoRaMac-api-v3.c LoRaMacCrypto.c
    ../Lib/LoRawan-node/misc/: utilities.c
    ../Lib/LoRawan-node/crypto/: aes.c cmac.c
  group Contiki\core\Sys
    ../contiki-3.0/core/sys/: autostart.c process.c timer.c etimer.c stimer.c rtimer-arch.c rtimer.c ctimer.c
  group Contiki\Clock
    ../contiki-3.0/cpu/arm/stm32f103/: clock.c
  group Contiki\core\lib
    ../contiki-3.0/core/lib/: aes-128.c assert.c ccm-star.c crc16.c gcr.c ifft.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c sensors.c settings.c trickle-timer.c
  group Contiki\core\net
    ../contiki-3.0/core/net/: linkaddr.c nbr-table.c netstack.c packetbuf.c queuebuf.c
  group Contiki\core\net\mac
    ../contiki-3.0/core/net/mac/contikimac/: contikimac.c contikimac-framer.c
    ../contiki-3.0/core/net/mac/: csma.c frame802154.c framer.c framer-802154.c framer-nullmac.c mac.c mac-sequence.c nullmac.c nullrdc.c nullrdc-noframer.c phase.c
  group Contiki\core\net\rime
    ../contiki-3.0/core/net/rime/: abc.c announcement.c broadcast.c broadcast-announcement.c chameleon.c chameleon-bitopt.c chameleon-raw.c channel.c collect.c collect-link-estimate.c collect-neighbor.c ipolite.c mesh.c multihop.c neighbor-discovery.c netflood.c packetqueue.c polite.c polite-announcement.c rime.c rimestats.c rmh.c route.c route-discovery.c rucb.c rudolph1.c rudolph2.c runicast.c stbroadcast.c stunicast.c timesynch.c trickle.c unicast.c
  group Contiki\core\net\llsec
    ../contiki-3.0/core/net/llsec/: anti-replay.c ccm-star-packetbuf.c nullsec.c
    ../contiki-3.0/core/net/llsec/noncoresec/: noncoresec.c
  group Contiki\core\dev
    ../contiki-3.0/core/dev/: nullradio.c
  group Contiki\rime
    ../contiki-3.0/examples/rime/: example-abc.c example-announcement.c example-broadcast.c example-collect.c example-mesh.c example-multihop.c example-neighbors.c example-polite.c example-rucb.c example-rudolph1.c example-rudolph2.c example-runicast.c example-trickle.c example-unicast.c
  group USER
    ../USER/: main.c stm32l0xx_it.c user-app.c LoRa-cad.c timer-app.c binhex.c
  group TEST
    ../TEST/: rtc_main.c test_lora_pingpong.c
  group DOC
    ../DOC/: readme.txt
